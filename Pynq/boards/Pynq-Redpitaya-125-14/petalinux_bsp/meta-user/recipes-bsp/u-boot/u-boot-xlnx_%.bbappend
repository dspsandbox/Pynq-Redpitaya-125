FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " file://read-mac-eeprom-fw-env.patch"


